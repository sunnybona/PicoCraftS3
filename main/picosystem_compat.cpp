#include "picosystem.hpp"

#include <cstdio>
#include <cstring>
#include <algorithm>

#include "esp_timer.h"
#include "freertos/FreeRTOS.h"
#include "freertos/task.h"

#include "board_config.h"
#include "input.hpp"

namespace picosystem {

// ---------------------------------------------------------------------------
// Built-in 8x8 font (96 glyphs; first byte = width, next 8 bytes = row bits)
// ---------------------------------------------------------------------------
static const uint8_t k_font[96][9] = {
  {2, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
  {2, 0xc0, 0xc0, 0xc0, 0xc0, 0xc0, 0x00, 0xc0, 0x00},
  {5, 0xd8, 0xd8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
  {7, 0x00, 0x6c, 0xfe, 0x6c, 0x6c, 0xfe, 0x6c, 0x00},
  {6, 0x00, 0x30, 0x7c, 0xf0, 0xfc, 0x3c, 0xf8, 0x30},
  {7, 0x00, 0xc6, 0xcc, 0x18, 0x30, 0x66, 0xc6, 0x00},
  {6, 0x00, 0x78, 0xcc, 0x78, 0xdc, 0xd8, 0x74, 0x00},
  {2, 0x00, 0xc0, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x00},
  {3, 0x00, 0x60, 0xc0, 0xc0, 0xc0, 0xc0, 0x60, 0x00},
  {3, 0x00, 0xc0, 0x60, 0x60, 0x60, 0x60, 0xc0, 0x00},
  {6, 0x00, 0x30, 0x30, 0xfc, 0x30, 0x78, 0xcc, 0x00},
  {6, 0x00, 0x00, 0x30, 0x30, 0xfc, 0x30, 0x30, 0x00},
  {2, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xc0, 0xc0},
  {5, 0x00, 0x00, 0x00, 0x00, 0xf8, 0x00, 0x00, 0x00},
  {2, 0x00, 0x00, 0x00, 0x00, 0x00, 0xc0, 0xc0, 0x00},
  {4, 0x00, 0x30, 0x30, 0x60, 0x60, 0xc0, 0xc0, 0x00},
  {5, 0x70, 0xd8, 0xd8, 0xf8, 0xd8, 0xd8, 0x70, 0x00},
  {5, 0x30, 0x70, 0xf0, 0x30, 0x30, 0x30, 0x78, 0x00},
  {5, 0x70, 0x98, 0x18, 0x30, 0x60, 0xc0, 0xf8, 0x00},
  {5, 0x70, 0x98, 0x18, 0x70, 0x18, 0x98, 0x70, 0x00},
  {5, 0xc0, 0xc0, 0xc0, 0xd8, 0xf8, 0x18, 0x18, 0x00},
  {5, 0xf8, 0xc0, 0xc0, 0xf0, 0x18, 0x98, 0x70, 0x00},
  {5, 0x70, 0xc8, 0xc0, 0xf0, 0xd8, 0xd8, 0x70, 0x00},
  {5, 0xf8, 0x18, 0x30, 0x30, 0x60, 0x60, 0x60, 0x00},
  {5, 0x70, 0xd8, 0xd8, 0x70, 0xd8, 0xd8, 0x70, 0x00},
  {5, 0x70, 0xd8, 0xd8, 0x78, 0x18, 0x98, 0x70, 0x00},
  {2, 0x00, 0x00, 0xc0, 0xc0, 0x00, 0xc0, 0xc0, 0x00},
  {2, 0x00, 0x00, 0xc0, 0xc0, 0x00, 0xc0, 0xc0, 0xc0},
  {4, 0x00, 0x00, 0x30, 0x60, 0xc0, 0x60, 0x30, 0x00},
  {5, 0x00, 0x00, 0x00, 0xf8, 0x00, 0xf8, 0x00, 0x00},
  {4, 0x00, 0x00, 0xc0, 0x60, 0x30, 0x60, 0xc0, 0x00},
  {6, 0x78, 0xcc, 0x0c, 0x38, 0x30, 0x00, 0x30, 0x00},
  {6, 0x00, 0x78, 0xcc, 0xdc, 0xdc, 0xc0, 0x78, 0x00},
  {6, 0x78, 0xcc, 0xcc, 0xcc, 0xfc, 0xcc, 0xcc, 0x00},
  {6, 0xf8, 0xcc, 0xcc, 0xf8, 0xcc, 0xcc, 0xf8, 0x00},
  {6, 0x78, 0xcc, 0xc0, 0xc0, 0xc0, 0xcc, 0x78, 0x00},
  {6, 0xf8, 0xcc, 0xcc, 0xcc, 0xcc, 0xcc, 0xf8, 0x00},
  {5, 0xf8, 0xc0, 0xc0, 0xf0, 0xc0, 0xc0, 0xf8, 0x00},
  {5, 0xf8, 0xc0, 0xc0, 0xf0, 0xc0, 0xc0, 0xc0, 0x00},
  {6, 0x78, 0xcc, 0xcc, 0xc0, 0xdc, 0xcc, 0x7c, 0x00},
  {6, 0xcc, 0xcc, 0xcc, 0xfc, 0xcc, 0xcc, 0xcc, 0x00},
  {6, 0xfc, 0x30, 0x30, 0x30, 0x30, 0x30, 0xfc, 0x00},
  {6, 0x0c, 0x0c, 0x0c, 0x0c, 0xcc, 0xcc, 0x78, 0x00},
  {6, 0xcc, 0xcc, 0xd8, 0xf0, 0xd8, 0xcc, 0xcc, 0x00},
  {5, 0xc0, 0xc0, 0xc0, 0xc0, 0xc0, 0xc0, 0xf8, 0x00},
  {7, 0xee, 0xfe, 0xd6, 0xc6, 0xc6, 0xc6, 0xc6, 0x00},
  {6, 0xcc, 0xec, 0xdc, 0xcc, 0xcc, 0xcc, 0xcc, 0x00},
  {6, 0x78, 0xcc, 0xcc, 0xcc, 0xcc, 0xcc, 0x78, 0x00},
  {6, 0xf8, 0xcc, 0xcc, 0xcc, 0xf8, 0xc0, 0xc0, 0x00},
  {6, 0x78, 0xcc, 0xcc, 0xcc, 0xec, 0xdc, 0x78, 0x00},
  {6, 0xf8, 0xcc, 0xcc, 0xcc, 0xf8, 0xcc, 0xcc, 0x00},
  {6, 0x78, 0xcc, 0xc0, 0x78, 0x0c, 0xcc, 0x78, 0x00},
  {6, 0xfc, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x00},
  {6, 0xcc, 0xcc, 0xcc, 0xcc, 0xcc, 0xcc, 0x78, 0x00},
  {6, 0xcc, 0xcc, 0xcc, 0xcc, 0xcc, 0x78, 0x30, 0x00},
  {7, 0xc6, 0xc6, 0xc6, 0xc6, 0xd6, 0xfe, 0xee, 0x00},
  {6, 0xcc, 0xcc, 0x78, 0x30, 0x78, 0xcc, 0xcc, 0x00},
  {6, 0xcc, 0xcc, 0xcc, 0x78, 0x30, 0x30, 0x30, 0x00},
  {6, 0xfc, 0x0c, 0x18, 0x30, 0x60, 0xc0, 0xfc, 0x00},
  {4, 0xf0, 0xc0, 0xc0, 0xc0, 0xc0, 0xc0, 0xf0, 0x00},
  {4, 0x00, 0xc0, 0xc0, 0x60, 0x60, 0x30, 0x30, 0x00},
  {4, 0xf0, 0x30, 0x30, 0x30, 0x30, 0x30, 0xf0, 0x00},
  {6, 0x00, 0x30, 0x78, 0xcc, 0x00, 0x00, 0x00, 0x00},
  {8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xff},
  {3, 0x00, 0xc0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00},
  {5, 0x00, 0x00, 0x70, 0x18, 0x78, 0xd8, 0x78, 0x00},
  {5, 0xc0, 0xc0, 0xf0, 0xd8, 0xd8, 0xd8, 0xf0, 0x00},
  {4, 0x00, 0x00, 0x70, 0xc0, 0xc0, 0xc0, 0x70, 0x00},
  {5, 0x18, 0x18, 0x78, 0xd8, 0xd8, 0xd8, 0x78, 0x00},
  {5, 0x00, 0x00, 0x70, 0xd8, 0xf8, 0xc0, 0x78, 0x00},
  {5, 0x38, 0x60, 0x60, 0xf8, 0x60, 0x60, 0x60, 0x00},
  {5, 0x00, 0x00, 0x78, 0xd8, 0xd8, 0x78, 0x18, 0x70},
  {5, 0xc0, 0xc0, 0xf0, 0xd8, 0xd8, 0xd8, 0xd8, 0x00},
  {2, 0x00, 0xc0, 0x00, 0xc0, 0xc0, 0xc0, 0xc0, 0x00},
  {3, 0x60, 0x60, 0x00, 0x60, 0x60, 0x60, 0x60, 0xc0},
  {5, 0xc0, 0xc0, 0xd8, 0xf0, 0xe0, 0xf0, 0xd8, 0x00},
  {2, 0xc0, 0xc0, 0xc0, 0xc0, 0xc0, 0xc0, 0xc0, 0x00},
  {7, 0x00, 0x00, 0xfc, 0xd6, 0xc6, 0xc6, 0xc6, 0x00},
  {5, 0x00, 0x00, 0xf0, 0xd8, 0xd8, 0xd8, 0xd8, 0x00},
  {5, 0x00, 0x00, 0x70, 0xd8, 0xd8, 0xd8, 0x70, 0x00},
  {5, 0x00, 0x00, 0xf0, 0xd8, 0xd8, 0xd8, 0xf0, 0xc0},
  {5, 0x00, 0x00, 0x78, 0xd8, 0xd8, 0xd8, 0x78, 0x18},
  {5, 0x00, 0x00, 0xf0, 0xd8, 0xc0, 0xc0, 0xc0, 0x00},
  {4, 0x00, 0x00, 0x70, 0xc0, 0xf0, 0x30, 0xe0, 0x00},
  {3, 0xc0, 0xc0, 0xe0, 0xc0, 0xc0, 0xc0, 0x60, 0x00},
  {5, 0x00, 0x00, 0xd8, 0xd8, 0xd8, 0xd8, 0x68, 0x00},
  {5, 0x00, 0x00, 0xd8, 0xd8, 0xd8, 0x70, 0x20, 0x00},
  {7, 0x00, 0x00, 0xc6, 0xc6, 0xc6, 0xd6, 0x6c, 0x00},
  {6, 0x00, 0x00, 0xcc, 0x78, 0x30, 0x78, 0xcc, 0x00},
  {5, 0x00, 0x00, 0xd8, 0xd8, 0xd8, 0x78, 0x18, 0x70},
  {5, 0x00, 0x00, 0xf8, 0x30, 0x60, 0xc0, 0xf8, 0x00},
  {4, 0x70, 0x60, 0x60, 0xc0, 0x60, 0x60, 0x70, 0x00},
  {2, 0xc0, 0xc0, 0xc0, 0xc0, 0xc0, 0xc0, 0xc0, 0xc0},
  {4, 0xe0, 0x60, 0x60, 0x30, 0x60, 0x60, 0xe0, 0x00},
  {6, 0x00, 0x00, 0x74, 0xd8, 0x00, 0x00, 0x00, 0x00},
  {0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
};

// ---------------------------------------------------------------------------
// Logical framebuffer (GBAR, 120x120)
// ---------------------------------------------------------------------------
static color_t s_fb[SCREEN_W * SCREEN_H];
static buffer_t s_screen = { SCREEN_W, SCREEN_H, s_fb, false };

color_t   _pen = 0;
buffer_t *SCREEN = &s_screen;
buffer_t *_dt = SCREEN;
int32_t   _cx = 0, _cy = 0, _cw = SCREEN_W, _ch = SCREEN_H;
int32_t   _tx = 0, _ty = 0;
int32_t   _camx = 0, _camy = 0;
const uint8_t *_font = &k_font[0][0];

buffer_t::~buffer_t() {
    if (alloc) delete[] data;
}

// ---------------------------------------------------------------------------
// State setters
// ---------------------------------------------------------------------------
void pen() { _pen = rgb(15, 15, 15, 15); }
void pen(uint8_t r, uint8_t g, uint8_t b, uint8_t a) { _pen = rgb(r, g, b, a); }
void pen(color_t p) { _pen = p; }

void target() { _dt = SCREEN; clip(); }
void target(buffer_t *dt) { _dt = dt; clip(); }

void clip() { _cx = 0; _cy = 0; _cw = _dt->w; _ch = _dt->h; }
void clip(int32_t x, int32_t y, uint32_t w, uint32_t h) {
    _cx = x; _cy = y; _cw = (int32_t)w; _ch = (int32_t)h;
}

void camera() { _camx = 0; _camy = 0; }
void camera(int32_t x, int32_t y) { _camx = x; _camy = y; }

void cursor() { _tx = 0; _ty = 0; }
void cursor(int32_t x, int32_t y) { _tx = x; _ty = y; }

// ---------------------------------------------------------------------------
// Primitives (COPY semantics directly into the GBAR target)
// ---------------------------------------------------------------------------
void pixel(int32_t x, int32_t y) {
    x -= _camx;
    y -= _camy;
    if (x >= _cx && x < _cx + _cw && y >= _cy && y < _cy + _ch) {
        *_dt->p(x, y) = _pen;
    }
}

void clear() { frect(_cx, _cy, (uint32_t)_cw, (uint32_t)_ch); }

void frect(int32_t x, int32_t y, int32_t w, int32_t h) {
    x -= _camx;
    y -= _camy;
    int32_t x0 = std::max(x, _cx);
    int32_t y0 = std::max(y, _cy);
    int32_t x1 = std::min(x + w, _cx + _cw);
    int32_t y1 = std::min(y + h, _cy + _ch);
    for (int32_t yy = y0; yy < y1; yy++) {
        for (int32_t xx = x0; xx < x1; xx++) {
            *_dt->p(xx, yy) = _pen;
        }
    }
}

void hline(int32_t x, int32_t y, int32_t l) {
    y -= _camy;
    x -= _camx;
    if (y < _cy || y >= _cy + _ch) return;
    int32_t x0 = std::max(x, _cx);
    int32_t x1 = std::min(x + l, _cx + _cw);
    for (int32_t xx = x0; xx < x1; xx++) *_dt->p(xx, y) = _pen;
}

void vline(int32_t x, int32_t y, int32_t l) {
    x -= _camx;
    y -= _camy;
    if (x < _cx || x >= _cx + _cw) return;
    int32_t y0 = std::max(y, _cy);
    int32_t y1 = std::min(y + l, _cy + _ch);
    for (int32_t yy = y0; yy < y1; yy++) *_dt->p(x, yy) = _pen;
}

void line(int32_t x1, int32_t y1, int32_t x2, int32_t y2) {
    int32_t x = x1, y = y1;
    int32_t dx = (x2 >= x1) ? (x2 - x1) : (x1 - x2);
    int32_t dy = (y2 >= y1) ? (y2 - y1) : (y1 - y2);
    int32_t incx = (x2 >= x1) ? 1 : -1;
    int32_t incy = (y2 >= y1) ? 1 : -1;

    if (dx >= dy) {
        dy <<= 1;
        int32_t balance = dy - dx;
        dx <<= 1;
        while (x != x2) {
            pixel(x, y);
            if (balance >= 0) { y += incy; balance -= dx; }
            balance += dy;
            x += incx;
        }
    } else {
        dx <<= 1;
        int32_t balance = dx - dy;
        dy <<= 1;
        while (y != y2) {
            pixel(x, y);
            if (balance >= 0) { x += incx; balance -= dy; }
            balance += dx;
            y += incy;
        }
    }
}

void rect(int32_t x, int32_t y, int32_t w, int32_t h) {
    hline(x, y, w);
    hline(x, y + h - 1, w);
    vline(x, y + 1, h - 2);
    vline(x + w - 1, y + 1, h - 2);
}

// ---------------------------------------------------------------------------
// Text
// ---------------------------------------------------------------------------
static void draw_char(char c) {
    if (c < 32 || c > 127) { _tx += 4; return; }
    const uint8_t *p = k_font[(c - 32)];
    uint8_t w = *p++;
    for (int row = 0; row < 8; row++) {
        uint8_t bits = *p++;
        for (int col = 0; col < w; col++) {
            if (bits & 0x80) pixel(_tx + col, _ty + row);
            bits <<= 1;
        }
    }
    _tx += w + 1;
}

void text(const std::string_view &t, int32_t x, int32_t y, int32_t wrap) {
    (void)wrap;
    _tx = x;
    _ty = y;
    for (char c : t) {
        if (c == '\n') { _tx = x; _ty += 8; continue; }
        draw_char(c);
    }
}

void text(const std::string_view &t, int32_t wrap) {
    (void)wrap;
    int32_t x = _tx;
    for (char c : t) {
        if (c == '\n') { _tx = x; _ty += 8; continue; }
        draw_char(c);
    }
}

// ---------------------------------------------------------------------------
// Utility
// ---------------------------------------------------------------------------
color_t rgb(uint8_t r, uint8_t g, uint8_t b, uint8_t a) {
    // GBAR: aaaarrrrggggbbbb
    return (color_t)((r & 0xf) | ((a & 0xf) << 4) | ((b & 0xf) << 8) | ((g & 0xf) << 12));
}

buffer_t *buffer(uint32_t w, uint32_t h, void *data) {
    buffer_t *b = new buffer_t();
    b->w = (int32_t)w;
    b->h = (int32_t)h;
    if (data) {
        b->data = (color_t *)data;
        b->alloc = false;
    } else {
        b->data = new color_t[w * h]();
        b->alloc = true;
    }
    return b;
}

uint32_t time_us() { return (uint32_t)esp_timer_get_time(); }
uint32_t time() { return time_us() / 1000u; }
void sleep(uint32_t d) { vTaskDelay(pdMS_TO_TICKS(d)); }

std::string str(int32_t v) {
    char b[32];
    snprintf(b, sizeof(b), "%ld", (long)v);
    return b;
}
std::string str(uint32_t v) {
    char b[32];
    snprintf(b, sizeof(b), "%lu", (unsigned long)v);
    return b;
}
std::string str(std::size_t v) { return str((uint32_t)v); }
std::string str(float v, uint8_t precision) {
    char b[32];
    snprintf(b, sizeof(b), "%.*f", (int)precision, v);
    return b;
}

// ---------------------------------------------------------------------------
// Input (forward to the GPIO driver)
// ---------------------------------------------------------------------------
bool button(uint32_t b) { return input_level((int)b); }
bool pressed(uint32_t b) { return input_pressed((int)b); }
bool released(uint32_t b) { return input_released((int)b); }

}
